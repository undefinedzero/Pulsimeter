# Keil uVision project stc51.uvproj, settings and files
target stc51 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: stc51 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: stc51.c
